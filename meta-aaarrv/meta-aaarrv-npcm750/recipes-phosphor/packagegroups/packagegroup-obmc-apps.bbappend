RDEPENDS_${PN}-extras_append = " oem-ipmi-handler"