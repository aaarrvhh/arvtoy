RDEPENDS_${PN}-buv-common-utils_append = " nuvoton-ipmi-oem"